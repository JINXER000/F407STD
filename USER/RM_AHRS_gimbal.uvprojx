# Keil uVision project RM_AHRS_gimbal.uvprojx, settings and files
target LED (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE;..\HARDWARE\imu_driver;..\HARDWARE\StringDecoding;..\HARDWARE\ESP8266;..\HARDWARE\pwm;..\HARDWARE\ano_frame;..\HARDWARE\bgcpid;..\HARDWARE\gradu;..\HARDWARE\gradu
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c niming.c
    ../HARDWARE/ano_frame/: scheduler.c time.c
    ../HARDWARE/bgcpid/: pid.c svpwm.c utilities.c drv_irq.c
    ../HARDWARE/gradu/: gradu_motor.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ./: timer.c DMA.c UART.c
    ../HARDWARE/imu_driver/: imu.c mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c out6050_i2c.c out6050_driver.c out6050_interrupt.c outimu.c
    ../HARDWARE/ESP8266/: Driver_ESP8266.c
    ../HARDWARE/StringDecoding/: StringDecoding.c
    ../HARDWARE/pwm/: pwm.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_wwdg.c
  group README
    ../: readme.txt
